# Keil uVision project PP16_FT81x.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L4R5ZGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.6.2
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) XRAM(0x20040000,0x00060000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: PP16_FT81x
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32L4R5xx, PP16_PLATFORM
  c include: ..\..\..\PP_Library_C_hub\PP_Hardware_Library;..\..\..\PP_Library_C_hub\PP_STM32_Periph_Library;..\..\..\PP_Library_C_hub;..\..\..\PP_Library_C_hub\PP_Queue;..\..\..\PP_Library_C_hub\PP_Param;..\..\..\PP_Library_C_hub\PP_Delay;..\..\..\PP_Library_C_hub\PP_Math;..\..\..\PP_Library_C_hub\PP_Pins;..\..\..\PP_Library_C_hub\PP_LCDgraph_Library;.
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT6: RAM 0x20040000 size 0x60000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group UserCode
    ../../../PP_Library_C_hub/PP_Delay/: delay.c
    ../../../PP_Library_C_hub/PP_Pins/: platform_io_signals.h config.h
    ./: main.c pp16_config.c
  group Screen
    ../../../PP_Library_C_hub/PP_LCDgraph_Library/: FT_Gpu.h pp_tftgraph_ft8xx.c
  group IOdevice
    ../../../PP_Library_C_hub/PP_Hardware_Library/: pp_extram_quadspi_ft8xx.c
    ../../../PP_Library_C_hub/PP_STM32_Periph_Library/: pp_extram_defines.h pp_extram_quadspi.c
  group Sem_Queue_List
    ../../../PP_Library_C_hub/PP_Queue/: pp_queue_with_timeout.c pp_queue.c
  group Math
    ../../../PP_Library_C_hub/PP_Math/: pp_math.c
software components: CMSIS:CORE 5.6.0, Device:Startup 1.3.1
